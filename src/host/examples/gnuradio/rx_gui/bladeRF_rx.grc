<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bladeRF_rx</value></param>
<param><key>author</key><value>Nuand, LLC &lt;bladeRF@nuand.com&gt;</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A simple RX-only GUI that demonstrates the usage of various RX controls.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>"Simple bladeRF RX GUI"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bladerf_args</value></param>
<param><key>value</key><value>"bladerf=" + bladerf_selection + ",buffers=" + str(num_buffers) + ",buflen=" + str(buflen) + ",num_xfers=" + str(num_xfers) + ",verbosity="+verbosity</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bladerf_selection</value></param>
<param><key>value</key><value>str(instance) if serial == "" else serial</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>gui_bladerf_args</value></param>
<param><key>value</key><value>bladerf_args</value></param>
<param><key>gui_hint</key><value>11, 0, 1, 10</value></param>
<param><key>label</key><value>"bladeRF arguments"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_dc_offset_i</value></param>
<param><key>value</key><value>dc_offset_i</value></param>
<param><key>gui_hint</key><value>1, 4, 1, 2</value></param>
<param><key>label</key><value>I DC Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>(1.0 / 2048.0)</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_dc_offset_q</value></param>
<param><key>value</key><value>dc_offset_q</value></param>
<param><key>gui_hint</key><value>1, 6, 1, 2</value></param>
<param><key>label</key><value>Q DC Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>(1.0 / 2048.0)</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_bandwidth</value></param>
<param><key>value</key><value>rx_bandwidth</value></param>
<param><key>gui_hint</key><value>1, 2, 1, 2</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5e6</value></param>
<param><key>step</key><value>0.5e6</value></param>
<param><key>stop</key><value>28e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_frequency</value></param>
<param><key>value</key><value>rx_frequency</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 5</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>3.8e9</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>gui_rx_lna_gain</value></param>
<param><key>value</key><value>rx_lna_gain</value></param>
<param><key>gui_hint</key><value>0, 9, 1, 1</value></param>
<param><key>label0</key><value>0 dB</value></param>
<param><key>label1</key><value>3 dB</value></param>
<param><key>label2</key><value>6 dB</value></param>
<param><key>label</key><value>LNA Gain</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>3</value></param>
<param><key>option2</key><value>6</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_sample_rate</value></param>
<param><key>value</key><value>rx_sample_rate</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 2</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5e6</value></param>
<param><key>step</key><value>500e3</value></param>
<param><key>stop</key><value>40e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_rx_vga_gain</value></param>
<param><key>value</key><value>rx_vga_gain</value></param>
<param><key>gui_hint</key><value>0, 5, 1, 4</value></param>
<param><key>label</key><value>RX VGA1 + VGA2 Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>gui_dc_offset_i</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>gui_dc_offset_q</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>buflen</value></param>
<param><key>label</key><value>Length of buffers, in samples. Should be a multiple of 1024.</value></param>
<param><key>value</key><value>4096</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dc_offset_i</value></param>
<param><key>label</key><value>DC offset compensation for I channel</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dc_offset_q</value></param>
<param><key>label</key><value>DC offset compensation for Q channel</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>gui_rx_frequency</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2, 0, 5, 10</value></param>
<param><key>freq_span</key><value>gui_rx_sample_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>instance</value></param>
<param><key>label</key><value>0-indexed device instance describing device to use. Ignored if a serial-number is provided.</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Command line params</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>GUI Controls</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>When enabling the fosphor sink, disable the Qt Frequency and Waterfall sinks.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>TO DO:  Expose bladeRF's internal DC offset compensation in the gr-osmosdr block and use this instead.</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_buffers</value></param>
<param><key>label</key><value>Number of buffers to use</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_xfers</value></param>
<param><key>label</key><value>Number of maximum in-flight USB transfers. Should be &lt;= (num-buffers / 2).</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>gui_rx_vga_gain</value></param>
<param><key>bw0</key><value>gui_rx_bandwidth</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>freq0</key><value>gui_rx_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>gui_rx_lna_gain</value></param>
<param><key>args</key><value>bladerf_args</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>gui_rx_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>gui_rx_sample_rate</value></param>
<param><key>fc</key><value>gui_rx_frequency</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>2, 0, 5, 5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>bw</key><value>gui_rx_sample_rate</value></param>
<param><key>fc</key><value>gui_rx_frequency</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>gui_hint</key><value>2, 0, 5, 5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>gui_rx_sample_rate</value></param>
<param><key>fc</key><value>gui_rx_frequency</value></param>
<param><key>fftsize</key><value>8192</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>7, 0, 3, 10</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>8192</value></param>
<param><key>srate</key><value>rx_sample_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_bandwidth</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_frequency</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>435924000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_lna_gain</value></param>
<param><key>label</key><value>RX LNA Gain</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_sample_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4800000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_vga_gain</value></param>
<param><key>label</key><value>RX VGA1 + VGA2 Gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>serial</value></param>
<param><key>label</key><value>bladeRF serial number</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>verbosity</value></param>
<param><key>label</key><value>libbladeRF log verbosity. Options are: verbose, debug, info, warning, error, critical, silent</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"info"</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
